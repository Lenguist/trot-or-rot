Commit message: WIP: snapshot before laptop wipe
Co-Authored-By: Claude Sonnet 5.5 <noreply@anthropic.com>

File: simulation/urdf-assembly.urdf (robot description, URDF)
Before this commit: robot urdf-assembly, 9 links, 8 joints
Links:
- link base-combined-v1: mass 1.5 -> 5.5
